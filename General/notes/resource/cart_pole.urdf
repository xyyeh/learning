Commit message: Working copy of dircol for cart_pole

File: General/notes/resource/cart_pole.urdf (robot description, URDF)
Before this commit: robot physics, 3 links, 2 joints
Joints:
- joint cart_to_pole: origin xyz=0.0 0.0 0 -> xyz=0.0 0.0 0 rpy=3.14159265 0 0
