Commit message: updates

File: General/notes/resource/fixed.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 2 links, 1 joints
Joints:
- joint joint_baseLink_childA: axis 1 0 0 -> (none)
