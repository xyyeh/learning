Commit message: Initial commit of simple robot using pybullet

File: General/notes/resource/four_dof.urdf (robot description, URDF)
Before this commit: robot FourJointRobot, 5 links, 4 joints
Links:
- link link_1: mass 2 -> 1
